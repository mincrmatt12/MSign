File: board/rev2/mainboard.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: More board stuff
(better clk routing, etc.)
Other:
- added sheet Decoder (decoder.kicad_sch)
